options:
  parameters:
    author: diego
    description: RTL-SDR 01 Pattern Receiver for Field Testing
    generate_options: qt_gui
    id: rtlsdr_rx_01
    output_language: python
    title: RTL-SDR 01 Pattern Receiver
  states: {}

blocks:
- name: bitrate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: '4000'
  states: {}
- name: filter_cutoff
  id: variable
  parameters:
    value: deviation + bitrate / 2 + 200
  states: {}
- name: filter_transition
  id: variable
  parameters:
    value: int(filter_cutoff / 4)
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: '433_000_000'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    start: '0'
    step: '1'
    stop: '50'
    value: '25'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2_160_000'
  states: {}
- name: sens
  id: variable
  parameters:
    value: samp_rate / (2 * math.pi * deviation)
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(samp_rate / bitrate)
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: sens
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: output_01.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: import_math
  id: import
  parameters:
    imports: import math, pmt, sys, os
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: filter_cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: filter_transition
    win: window.WIN_HAMMING
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: rf_freq
    dev_args: driver=rtlsdr
    freq_correction: '-15'
    gain: rx_gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_file_sink_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [soapy_rtlsdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0

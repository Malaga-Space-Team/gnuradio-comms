options:
  parameters:
    author: diego
    description: LimeSDR 2FSK RS Encoded Packet Transmitter
    generate_options: qt_gui
    id: limesdr_tx_rs
    output_language: python
    title: LimeSDR RS BFSK Transmitter
  states: {}

blocks:
- name: bitrate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: '4000'
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: '433_000_000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2_160_000'
  states: {}
- name: sensitivity
  id: variable
  parameters:
    value: 2 * math.pi * deviation / samp_rate
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(samp_rate / bitrate)
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: TX Gain
    start: '-12'
    step: '1'
    stop: '64'
    value: '64'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: sensitivity
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: input_rs.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: sps
    type: float
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[-1, 1]'
  states: {}
- name: import_math
  id: import
  parameters:
    imports: import math, pmt, sys, os
  states: {}
- name: soapy_limesdr_sink_0
  id: soapy_limesdr_sink
  parameters:
    center_freq: rf_freq
    gain: tx_gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', soapy_limesdr_sink_0, '0']
- [blocks_file_source_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_repeat_0, '0', analog_frequency_modulator_fc_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_repeat_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0

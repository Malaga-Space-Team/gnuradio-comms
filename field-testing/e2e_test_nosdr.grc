options:
  parameters:
    author: diego
    description: 2FSK End-to-End Software Simulation Loopback Test
    generate_options: no_gui
    id: e2e_test_nosdr
    output_language: python
    title: 2FSK Software Loopback E2E Test
  states: {}

blocks:
- name: bitrate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: '4000'
  states: {}
- name: filter_cutoff
  id: variable
  parameters:
    value: deviation + bitrate / 2 + 200
  states: {}
- name: filter_transition
  id: variable
  parameters:
    value: int(filter_cutoff / 4)
  states: {}
- name: noise_level
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2_160_000'
  states: {}
- name: sens
  id: variable
  parameters:
    value: samp_rate / (2 * math.pi * deviation)
  states: {}
- name: sensitivity
  id: variable
  parameters:
    value: 2 * math.pi * deviation / samp_rate
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(samp_rate / bitrate)
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: sensitivity
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_level
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: sens
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: output_nosdr.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: input.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: sps
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[-1, 1]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.basic_block):
          """CC120 Deframer"""
          def __init__(self, sync_word="11010110011111111110000011101", debug=False):
              gr.basic_block.__init__(self, name='CC1120 Deframer', in_sig=[np.uint8], out_sig=[np.uint8])
              self.debug = debug == "True"
              self.sync_word = sync_word.zfill(32)
              self.sync_len = len(self.sync_word)
              self.sync_val = int(self.sync_word, 2)
              self.sync_mask = (1 << self.sync_len) - 1
              self.state = "SYNC"
              self.shift_reg = 0
              self.payload_len = 0
              self.temp_payload_len = 0
              self.bit_counter = 0
              self.payload = []
              self.out_queue = []

          def forecast(self, noutput_items, ninputs):
              return [max(1, noutput_items * 8) for _ in range(ninputs)]

          def general_work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]
              for val in in0:
                  bit = int(val) & 1
                  if self.state == "SYNC":
                      self.shift_reg = ((self.shift_reg << 1) | bit) & self.sync_mask
                      if self.shift_reg == self.sync_val:
                          self.state = "LENGTH"
                          self.temp_payload_len = self.bit_counter = 0
                  elif self.state == "LENGTH":
                      self.temp_payload_len = (self.temp_payload_len << 1) | bit
                      self.bit_counter += 1
                      if self.bit_counter == 8:
                          self.payload_len = self.temp_payload_len
                          self.payload = []
                          if self.payload_len > 0:
                              self.state = "PAYLOAD"
                              self.temp_payload_len = self.bit_counter = 0
                          else:
                              self.state = "SYNC"
                              self.shift_reg = 0
                  elif self.state == "PAYLOAD":
                      self.temp_payload_len = (self.temp_payload_len << 1) | bit
                      self.bit_counter += 1
                      if self.bit_counter == 8:
                          self.payload.append(self.temp_payload_len)
                          self.temp_payload_len = self.bit_counter = 0
                          if len(self.payload) == self.payload_len:
                              self.out_queue.extend(self.payload)
                              self.state = "SYNC"
                              self.shift_reg = 0
              out_idx = 0
              while out_idx < len(out0) and len(self.out_queue) > 0:
                  out0[out_idx] = self.out_queue.pop(0)
                  out_idx += 1
              self.consume(0, len(in0))
              return out_idx
    debug: 'False'
    sync_word: '"11010110011111111110000011101"'
  states: {}
- name: import_math
  id: import
  parameters:
    imports: import math, pmt, sys, os
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: filter_cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: filter_transition
    win: window.WIN_HAMMING
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: signal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: signal
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_add_xx_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_quadrature_demod_cf_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_file_source_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_repeat_0, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_throttle2_0, '0', virtual_sink_0, '0']
- [digital_binary_slicer_fb_0, '0', epy_block_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_repeat_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [epy_block_0, '0', blocks_file_sink_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [virtual_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0

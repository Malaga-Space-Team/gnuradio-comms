options:
  parameters:
    author: diego
    description: RTL-SDR 2FSK Reed-Solomon Packet Receiver for Field Testing
    generate_options: qt_gui
    id: rtlsdr_rx_rs
    output_language: python
    title: RTL-SDR RS BFSK Packet Receiver
  states: {}

blocks:
- name: bitrate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: '4000'
  states: {}
- name: filter_cutoff
  id: variable
  parameters:
    value: deviation + bitrate / 2 + 200
  states: {}
- name: filter_transition
  id: variable
  parameters:
    value: int(filter_cutoff / 4)
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: '433_000_000'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    start: '0'
    step: '1'
    stop: '50'
    value: '25'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2_160_000'
  states: {}
- name: sens
  id: variable
  parameters:
    value: samp_rate / (2 * math.pi * deviation)
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(samp_rate / bitrate)
  states: {}
- name: sync_threshold
  id: variable
  parameters:
    value: '2'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: sens
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: output_rs.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import reedsolo

      class blk(gr.basic_block):
          """CC1120 Robust RS Stream Decoder"""
          def __init__(self, sync_word='00011010110011111111110000011101', threshold=2):
              gr.basic_block.__init__(self, name='CC1120 RS Stream Decoder', in_sig=[np.uint8], out_sig=[np.uint8])
              self.sync_bits = np.array([int(b) for b in sync_word], dtype=np.uint8)
              self.sync_len = len(self.sync_bits)
              self.threshold = threshold
              self.max_packet_len = 128
              self.rsc = reedsolo.RSCodec(4)
              self.state = 'SEARCH_SYNC'
              self.buffer = []
              self.len_bits = []
              self.payload_bits = []
              self.bits_needed = 0

          def forecast(self, noutput_items, ninputs):
              return [max(1, noutput_items * 8) for _ in range(ninputs)]

          def general_work(self, input_items, output_items):
              in_bits = input_items[0]
              out = output_items[0]
              in_idx = 0
              out_idx = 0
              while in_idx < len(in_bits):
                  if self.state == 'READ_PAYLOAD' and out_idx + self.max_packet_len > len(out):
                      break
                  bit = in_bits[in_idx]
                  in_idx += 1
                  if self.state == 'SEARCH_SYNC':
                      self.buffer.append(bit)
                      if len(self.buffer) > self.sync_len:
                          self.buffer.pop(0)
                      if len(self.buffer) == self.sync_len:
                          diffs = np.sum(np.array(self.buffer, dtype=np.uint8) != self.sync_bits)
                          if diffs <= self.threshold:
                              self.state = 'READ_LEN'
                              self.len_bits = []
                  elif self.state == 'READ_LEN':
                      self.len_bits.append(bit)
                      if len(self.len_bits) == 8:
                          pkt_len = int(np.packbits(self.len_bits)[0])
                          if 5 <= pkt_len <= self.max_packet_len:
                              self.bits_needed = pkt_len * 8
                              self.payload_bits = []
                              self.state = 'READ_PAYLOAD'
                          else:
                              self.state = 'SEARCH_SYNC'
                              self.buffer = []
                  elif self.state == 'READ_PAYLOAD':
                      self.payload_bits.append(bit)
                      if len(self.payload_bits) == self.bits_needed:
                          rs_codeword = bytes(np.packbits(self.payload_bits))
                          try:
                              decoded_payload, _, _ = self.rsc.decode(rs_codeword)
                          except Exception:
                              decoded_payload = rs_codeword[:max(0, len(rs_codeword) - 4)]
                          dec_arr = np.frombuffer(decoded_payload, dtype=np.uint8)
                          available_space = len(out) - out_idx
                          if len(dec_arr) <= available_space:
                              out[out_idx : out_idx + len(dec_arr)] = dec_arr
                              out_idx += len(dec_arr)
                          self.state = 'SEARCH_SYNC'
                          self.buffer = []
              self.consume(0, in_idx)
              return out_idx
    sync_word: '''00011010110011111111110000011101'''
    threshold: sync_threshold
  states: {}
- name: import_math
  id: import
  parameters:
    imports: import math, pmt, sys, os
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: filter_cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: filter_transition
    win: window.WIN_HAMMING
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: rf_freq
    dev_args: driver=rtlsdr
    freq_correction: '-15'
    gain: rx_gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', epy_block_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [epy_block_0, '0', blocks_file_sink_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [soapy_rtlsdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0

options:
  parameters:
    author: diego
    generate_options: qt_gui
    id: rtlsdr_rx_ccsds_yamcs
    output_language: python
    title: RTLSDR CCSDS Transmission Yamcs
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: afc_alpha
  id: variable
  parameters:
    value: 1 - math.exp(-2 * math.pi * 10 / rx_samp_rate)
  states: {}
- name: bitrate
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: channel_cutoff
  id: variable
  parameters:
    value: deviation + bitrate / 2 + 3_000
  states: {}
- name: channel_transition
  id: variable
  parameters:
    value: '12_000'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '15'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: '4000'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    label: frequency correction
    start: '-20000'
    step: '100'
    stop: '20000'
    value: '0'
  states: {}
- name: gain
  id: variable
  parameters:
    comment: Quadrature demodulator gain
    value: rx_samp_rate / (2.0 * math.pi * deviation)
  states: {}
- name: lpf
  id: variable
  parameters:
    comment: Low pass filter
    value: firdes.low_pass(1.0, samp_rate, channel_cutoff, channel_transition, window.WIN_HAMMING, 6.76)
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: '436_000_000'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    start: '-12'
    step: '1'
    stop: '64'
    value: '20'
  states: {}
- name: rx_offset
  id: variable
  parameters:
    comment: Offset for avoiding SDRs center DC spike
    value: '0'
  states: {}
- name: rx_samp_rate
  id: variable
  parameters:
    value: samp_rate / decim
  states: {}
- name: rx_sps
  id: variable
  parameters:
    value: rx_samp_rate / bitrate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2_160_000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(samp_rate / bitrate)
  states: {}
- name: yamcs_host
  id: variable
  parameters:
    comment: Yamcs server IP
    value: '"127.0.0.1"'
  states: {}
- name: yamcs_port
  id: variable
  parameters:
    comment: Yamcs Telemetry UDP Port
    value: '"10015"'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: gain
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    comment: |-
      Takes the average from the 15 previous samples
      Outputs a smother signal
    length: 'int(rx_sps) '
    max_iter: '1000'
    scale: 1.0 / rx_sps
    type: float
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    comment: |-
      When using COTS SDRs or when Doppler shift is not properly 
      compensated, a residual frequency offset may be present in 
      the received signal. To compensate for this effect, the mean 
      frequency deviation error is estimated and subtracted from 
      the demodulated signal.
    type: float
  states: {}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_key
    comment: Detect ASM 0x1ACFFC1D
    tagname: '"packet_len"'
    threshold: '0'
    type: byte
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: rx_sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-rx_offset - freq_offset'
    comment: |-
      Low pass filter + Signal Translation + Sample Rate decimation

      The sample rate is decimated by 15 in order to not load the CPU
    decim: decim
    samp_rate: samp_rate
    taps: lpf
    type: ccf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio import digital, filter, analog, network; from gnuradio.filter import firdes; from gnuradio.fft import window; import math, pmt
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    comment: Send Decoded CCSDS Space Packets to Yamcs via UDP
    host: yamcs_host
    mtu: '10000'
    port: yamcs_port
    type: UDP_CLIENT
  states: {}
- name: pdu_tagged_stream_to_pdu_1
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: (0, 2)
    label1: RF Spectrum
    name: '"Received Signal"'
    norm_window: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: (0, 1)
    label1: Demodulated Float Baseband
    name: '"Demodulated Signal"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: green
    gui_hint: (1, 0, 1, 2)
    label1: Sliced Bits (0 or 1)
    name: '"Recovered Signal"'
    size: '256'
    srate: bitrate
    type: float
    ylabel: Bit Value
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: afc_alpha
    comment: Estimates mean error of the demodulated signal (should be centered at 0)
    type: float
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: rf_freq + rx_offset
    comment: |-
      Not receiving in 436MHz because of the 
      DC Spike in the center of the carrier frequency
    gain: rx_gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: r1
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: r1
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_sub_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0, '0']
- [analog_quadrature_demod_cf_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_moving_average_xx_0, '0', digital_symbol_sync_xx_0_0, '0']
- [blocks_repack_bits_bb_1, '0', pdu_tagged_stream_to_pdu_1, '0']
- [blocks_sub_xx_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_uchar_to_float_1, '0', qtgui_time_sink_x_1, '0']
- [digital_binary_slicer_fb_0, '0', blocks_uchar_to_float_1, '0']
- [digital_binary_slicer_fb_0, '0', virtual_sink_2, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_binary_slicer_fb_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [pdu_tagged_stream_to_pdu_1, pdus, network_socket_pdu_0, pdus]
- [single_pole_iir_filter_xx_0, '0', blocks_sub_xx_0, '1']
- [soapy_rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [virtual_source_2, '0', digital_correlate_access_code_xx_ts_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0

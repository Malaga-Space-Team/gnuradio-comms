options:
  parameters:
    author: Diego
    generate_options: qt_gui
    id: ccsds_yamcs
    output_language: python
    title: CCSDS -> Yamcs Flowgraph
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: afc_alpha
  id: variable
  parameters:
    value: 1 - math.exp(-2 * math.pi * 10 / rx_samp_rate)
  states: {}
- name: bitrate
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: channel_cutoff
  id: variable
  parameters:
    value: deviation + bitrate / 2 + 3_000
  states: {}
- name: channel_transition
  id: variable
  parameters:
    value: '12_000'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '15'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: '4000'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    label: frequency correction
    start: '-20000'
    step: '100'
    stop: '20000'
    value: '0'
  states: {}
- name: gain
  id: variable
  parameters:
    comment: Quadrature demodulator gain
    value: rx_samp_rate / (2.0 * math.pi * deviation)
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: Header - ASM
    value: digital.header_format_default(access_key, 0, 1)
  states: {}
- name: lpf
  id: variable
  parameters:
    comment: Low pass filter
    value: firdes.low_pass(1.0, samp_rate, channel_cutoff, channel_transition, window.WIN_HAMMING, 6.76)
  states: {}
- name: rx_offset
  id: variable
  parameters:
    comment: Offset for avoiding SDRs center DC spike
    value: '0'
  states: {}
- name: rx_samp_rate
  id: variable
  parameters:
    value: samp_rate / decim
  states: {}
- name: rx_sps
  id: variable
  parameters:
    value: rx_samp_rate / bitrate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2_160_000'
  states: {}
- name: sens
  id: variable
  parameters:
    value: 2.0 * math.pi * deviation / samp_rate
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(samp_rate / bitrate)
  states: {}
- name: yamcs_host
  id: variable
  parameters:
    comment: Yamcs server IP
    value: '"127.0.0.1"'
  states: {}
- name: yamcs_port
  id: variable
  parameters:
    comment: Yamcs Telemetry UDP Port
    value: '"10015"'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: sens
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: gain
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    comment: |-
      0064c000000700000001410f22cf

      [0x55]*197 is the padding defined by CCSDS standard
    msg: pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(223, [0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x64, 0xc0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x41, 0x0f, 0x22, 0xcf, 0x07, 0xff, 0xc0, 0x00, 0x00, 0xc4] + [0x55]*197))
    period: '1000'
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    comment: |-
      Takes the average from the 15 previous samples
      Outputs a smother signal
    length: 'int(rx_sps) '
    max_iter: '1000'
    scale: 1.0 / rx_sps
    type: float
  states: {}
- name: blocks_packed_to_unpacked_bb_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: sps
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    comment: |-
      When using COTS SDRs or when Doppler shift is not properly 
      compensated, a residual frequency offset may be present in 
      the received signal. To compensate for this effect, the mean 
      frequency deviation error is estimated and subtracted from 
      the demodulated signal.
    type: float
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: (-1, 1)
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_key
    comment: Detect ASM 0x1ACFFC1D
    tagname: '"packet_len"'
    threshold: '0'
    type: byte
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    comment: Format Frame Header
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: rx_sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt


      def generate_ccsds_sequence(length=255):
          """Generates the CCSDS pseudo-random sequence using the generator polynomial
          h(x) = x^8 + x^7 + x^5 + x^3 + 1 (CCSDS 131.0-B) initialized to 0xFF.
          """
          seq = bytearray(length)
          state = 0xFF
          for i in range(length):
              byte = 0
              for _ in range(8):
                  out_bit = state & 1
                  feedback = ((state >> 0) ^ (state >> 3) ^ (state >> 5) ^ (state >> 7)) & 1
                  state = (state >> 1) | (feedback << 7)
                  byte = (byte << 1) | out_bit
              seq[i] = byte
          return np.frombuffer(seq, dtype=np.uint8)


      class blk(gr.basic_block):
          """CCSDS Scrambler implementation"""

          def __init__(self):
              gr.basic_block.__init__(self, name="CCSDS Scrambler", in_sig=None, out_sig=None)
              self.d_sequence = generate_ccsds_sequence(255)

              self.message_port_register_out(pmt.intern("out"))
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.msg_handler)

          def msg_handler(self, pmt_msg):
              msg = np.array(pmt.u8vector_elements(pmt.cdr(pmt_msg)), dtype=np.uint8)

              if msg.size > self.d_sequence.size:
                  self.d_sequence = generate_ccsds_sequence(msg.size)

              msg ^= self.d_sequence[: msg.size]

              self.message_port_pub(
                  pmt.intern("out"),
                  pmt.cons(pmt.car(pmt_msg), pmt.init_u8vector(msg.size, msg.tolist())),
              )
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-rx_offset - freq_offset'
    comment: |-
      Low pass filter + Signal Translation + Sample Rate decimation

      The sample rate is decimated by 15 in order to not load the CPU
    decim: decim
    samp_rate: samp_rate
    taps: lpf
    type: ccf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio import digital, filter, analog, network; from gnuradio.filter import firdes; from gnuradio.fft import window; import math, pmt
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    comment: Send Decoded CCSDS Space Packets to Yamcs via UDP
    host: yamcs_host
    mtu: '10000'
    port: yamcs_port
    type: UDP_CLIENT
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_1
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: (0, 0)
    label1: BFSK RF Spectrum (+-4 kHz Peaks)
    name: '"Transmitted Signal"'
    norm_window: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: (0, 1)
    label1: Demodulated Float Baseband
    name: '"Demodulated Signal"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: green
    gui_hint: (1, 0, 1, 2)
    label1: Sliced Bits (0 or 1)
    name: '"Recovered Signal"'
    size: '256'
    srate: bitrate
    type: float
    ylabel: Bit Value
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      # CCSDS 131.0-B Galois Field GF(256) tables
      # Field generator polynomial: F(x) = x^8 + x^7 + x^2 + x + 1 (0x187)
      # Code generator polynomial: g(x) = product_{j=112}^{143} (x - alpha^(11*j))
      ALPHA_TO = [
          0x01, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x87, 0x89, 0x95, 0xad, 0xdd, 0x3d,
          0x7a, 0xf4, 0x6f, 0xde, 0x3b, 0x76, 0xec, 0x5f, 0xbe, 0xfb, 0x71, 0xe2, 0x43, 0x86,
          0x8b, 0x91, 0xa5, 0xcd, 0x1d, 0x3a, 0x74, 0xe8, 0x57, 0xae, 0xdb, 0x31, 0x62, 0xc4,
          0x0f, 0x1e, 0x3c, 0x78, 0xf0, 0x67, 0xce, 0x1b, 0x36, 0x6c, 0xd8, 0x37, 0x6e, 0xdc,
          0x3f, 0x7e, 0xfc, 0x7f, 0xfe, 0x7b, 0xf6, 0x6b, 0xd6, 0x2b, 0x56, 0xac, 0xdf, 0x39,
          0x72, 0xe4, 0x4f, 0x9e, 0xbb, 0xf1, 0x65, 0xca, 0x13, 0x26, 0x4c, 0x98, 0xb7, 0xe9,
          0x55, 0xaa, 0xd3, 0x21, 0x42, 0x84, 0x8f, 0x99, 0xb5, 0xed, 0x5d, 0xba, 0xf3, 0x61,
          0xc2, 0x03, 0x06, 0x0c, 0x18, 0x30, 0x60, 0xc0, 0x07, 0x0e, 0x1c, 0x38, 0x70, 0xe0,
          0x47, 0x8e, 0x9b, 0xb1, 0xe5, 0x4d, 0x9a, 0xb3, 0xe1, 0x45, 0x8a, 0x93, 0xa1, 0xc5,
          0x0d, 0x1a, 0x34, 0x68, 0xd0, 0x27, 0x4e, 0x9c, 0xbf, 0xf9, 0x75, 0xea, 0x53, 0xa6,
          0xcb, 0x11, 0x22, 0x44, 0x88, 0x97, 0xa9, 0xd5, 0x2d, 0x5a, 0xb4, 0xef, 0x59, 0xb2,
          0xe3, 0x41, 0x82, 0x83, 0x81, 0x85, 0x8d, 0x9d, 0xbd, 0xfd, 0x7d, 0xfa, 0x73, 0xe6,
          0x4b, 0x96, 0xab, 0xd1, 0x25, 0x4a, 0x94, 0xaf, 0xd9, 0x35, 0x6a, 0xd4, 0x2f, 0x5e,
          0xbc, 0xff, 0x79, 0xf2, 0x63, 0xc6, 0x0b, 0x16, 0x2c, 0x58, 0xb0, 0xe7, 0x49, 0x92,
          0xa3, 0xc1, 0x05, 0x0a, 0x14, 0x28, 0x50, 0xa0, 0xc7, 0x09, 0x12, 0x24, 0x48, 0x90,
          0xa7, 0xc9, 0x15, 0x2a, 0x54, 0xa8, 0xd7, 0x29, 0x52, 0xa4, 0xcf, 0x19, 0x32, 0x64,
          0xc8, 0x17, 0x2e, 0x5c, 0xb8, 0xf7, 0x69, 0xd2, 0x23, 0x46, 0x8c, 0x9f, 0xb9, 0xf5,
          0x6d, 0xda, 0x33, 0x66, 0xcc, 0x1f, 0x3e, 0x7c, 0xf8, 0x77, 0xee, 0x5b, 0xb6, 0xeb,
          0x51, 0xa2, 0xc3, 0x00,
      ]

      INDEX_OF = [
          255, 0,   1,   99,  2,   198, 100, 106, 3,   205, 199, 188, 101, 126, 107, 42,
          4,   141, 206, 78,  200, 212, 189, 225, 102, 221, 127, 49,  108, 32,  43,  243,
          5,   87,  142, 232, 207, 172, 79,  131, 201, 217, 213, 65,  190, 148, 226, 180,
          103, 39,  222, 240, 128, 177, 50,  53,  109, 69,  33,  18,  44,  13,  244, 56,
          6,   155, 88,  26,  143, 121, 233, 112, 208, 194, 173, 168, 80,  117, 132, 72,
          202, 252, 218, 138, 214, 84,  66,  36,  191, 152, 149, 249, 227, 94,  181, 21,
          104, 97,  40,  186, 223, 76,  241, 47,  129, 230, 178, 63,  51,  238, 54,  16,
          110, 24,  70,  166, 34,  136, 19,  247, 45,  184, 14,  61,  245, 164, 57,  59,
          7,   158, 156, 157, 89,  159, 27,  8,   144, 9,   122, 28,  234, 160, 113, 90,
          209, 29,  195, 123, 174, 10,  169, 145, 81,  91,  118, 114, 133, 161, 73,  235,
          203, 124, 253, 196, 219, 30,  139, 210, 215, 146, 85,  170, 67,  11,  37,  175,
          192, 115, 153, 119, 150, 92,  250, 82,  228, 236, 95,  74,  182, 162, 22,  134,
          105, 197, 98,  254, 41,  125, 187, 204, 224, 211, 77,  140, 242, 31,  48,  220,
          130, 171, 231, 86,  179, 147, 64,  216, 52,  176, 239, 38,  55,  12,  17,  68,
          111, 120, 25,  154, 71,  116, 167, 193, 35,  83,  137, 251, 20,  93,  248, 151,
          46,  75,  185, 96,  15,  237, 62,  229, 246, 135, 165, 23,  58,  163, 60,  183,
      ]

      CCSDS_POLY = [
          0, 249, 59, 66, 4,   43, 126, 251, 97,  30,  3,  213, 50, 66, 170, 5, 24,
          5, 170, 66, 50, 213, 3,  30,  97,  251, 126, 43, 4,   66, 59, 249, 0,
      ]

      NROOTS = 32


      def encode_rs_ccsds(data):
          """Encodes a message using CCSDS 131.0-B Reed-Solomon (255, 223) conventional basis.

          Supports message length up to 223 bytes (full length or shortened via virtual fill).
          Returns a bytes object containing the original data with the 32 parity bytes appended.
          """
          parity = [0] * NROOTS
          for byte in data:
              feedback = INDEX_OF[byte ^ parity[0]]
              if feedback != 255:
                  for j in range(1, NROOTS):
                      parity[j] ^= ALPHA_TO[(feedback + CCSDS_POLY[NROOTS - j]) % 255]
                  p_last = ALPHA_TO[(feedback + CCSDS_POLY[0]) % 255]
              else:
                  p_last = 0
              parity = parity[1:] + [p_last]

          return bytes(data) + bytes(parity)


      class blk(gr.basic_block):
          """CCSDS Reed-Solomon (255, 223) Encoder

          Implementation according to CCSDS 131.0-B (Conventional Basis, Interleaving Depth = 1).
          Takes a PDU on the 'in' port, appends 32 RS parity bytes, and publishes the resulting PDU on 'out'.
          """

          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="CCSDS RS Encoder",
                  in_sig=None,
                  out_sig=None,
              )
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.msg_handler)

          def msg_handler(self, pmt_msg):
              data = np.array(pmt.u8vector_elements(pmt.cdr(pmt_msg)), dtype=np.uint8)

              if data.size > 223:
                  # Message exceeds maximum RS info length for depth 1
                  return

              encoded = encode_rs_ccsds(data)

              self.message_port_pub(
                  pmt.intern("out"),
                  pmt.cons(
                      pmt.car(pmt_msg),
                      pmt.init_u8vector(len(encoded), list(encoded)),
                  ),
              )
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: afc_alpha
    comment: Estimates mean error of the demodulated signal (should be centered at 0)
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: t1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: t2
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: r1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: t1
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: t2
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: r1
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_throttle2_0, '0']
- [analog_quadrature_demod_cf_0, '0', blocks_sub_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0, '0']
- [analog_quadrature_demod_cf_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_message_strobe_0, strobe, epy_block_1, in]
- [blocks_moving_average_xx_0, '0', digital_symbol_sync_xx_0_0, '0']
- [blocks_packed_to_unpacked_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_repack_bits_bb_1, '0', pdu_tagged_stream_to_pdu_1, '0']
- [blocks_repeat_0, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_sub_xx_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', virtual_sink_1, '0']
- [blocks_uchar_to_float_1, '0', qtgui_time_sink_x_1, '0']
- [digital_binary_slicer_fb_0, '0', blocks_uchar_to_float_1, '0']
- [digital_binary_slicer_fb_0, '0', virtual_sink_2, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_repeat_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_binary_slicer_fb_0, '0']
- [epy_block_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_pdu_to_tagged_stream_0, '0', digital_protocol_formatter_bb_0, '0']
- [pdu_tagged_stream_to_pdu_1, pdus, network_socket_pdu_0, pdus]
- [epy_block_1, out, epy_block_0, in]
- [single_pole_iir_filter_xx_0, '0', blocks_sub_xx_0, '1']
- [virtual_source_0, '0', blocks_packed_to_unpacked_bb_0, '0']
- [virtual_source_1, '0', freq_xlating_fir_filter_xxx_0, '0']
- [virtual_source_2, '0', digital_correlate_access_code_xx_ts_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
